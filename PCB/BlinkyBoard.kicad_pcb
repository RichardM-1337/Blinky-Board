# Repository RichardM-1337/Blinky-Board

File README.md:

# Blinky-Board
A pikachu shaped blinky board that will look dope on my desk!

This was basically another project that helped brush my KiCAD and PCB design skills again because I did step away from doing projects for a bit due to school. But of course, now I'm back!

# PCB
I did all the PCB and schematic stuff on KiCAD!

- Schematic
- 
- PCB Design
- 

# 3D View
This was also done using the 3D view option in KiCAD.

# BOM (Bill of Materials)
|Amount|Part Name|
|--|--|
|10|LEDS|
|1|NE555P|
|1|Conn 1x2 socket|
|1|Conn 1x1 socket|
|1|1k ohm resistor|
|1|470 ohm resistor|
|1|Potentiometer|
|1|0.01 uF Capacitor|
|1|1 uF Electrolytic capacitor|
|1|CD4017|
|1|PCB|

## KiCad design PCB/BlinkyBoard.kicad_pcb

Parts:
C1: 0.01uF; CP_Radial_D5.0mm_P2.00mm
C2: 1uF; C_Disc_D7.5mm_W2.5mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: LED; LED_D3.0mm
J1: Conn_01x02_Socket; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x01_Socket; PinHeader_1x01_P2.54mm_Vertical
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 50k; Potentiometer_Vishay_T93YA_Vertical
U1: NE555P; DIP-8_W7.62mm
U2: 4017; N16

Connections:
+5V: J1.1, R1.1, U1.4 (~RST), U1.8 (VCC), U2.16 (VDD)
GND: C1.1, C2.2, J1.2, R2.2, U1.1 (GND), U2.8 (VSS), U2.13 (CKEN), U2.15 (Reset)
unnamed: D1.2 (A), U2.3 (Q0)
unnamed: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), R2.1
unnamed: D2.2 (A), U2.2 (Q1)
unnamed: D3.2 (A), U2.4 (Q2)
unnamed: D4.2 (A), U2.7 (Q3)
unnamed: D5.2 (A), U2.10 (Q4)
unnamed: D6.2 (A), U2.1 (Q5)
unnamed: D7.2 (A), U2.5 (Q6)
unnamed: D8.2 (A), U2.6 (Q7)
unnamed: D9.2 (A), U2.9 (Q8)
unnamed: D10.2 (A), U2.11 (Q9)
unnamed: C1.2, U1.5 (CONT)
unnamed: R1.2, RV1.1, RV1.2, U1.7 (DISCH)
unnamed: RV1.3, U1.6 (THRES)
OUT: J2.1 (Pin_1_1), U1.3 (OUT), U2.14 (CLK)
TR: C2.1, U1.2 (TRIG)

Board: 2 copper layers, 82.7 x 89.3 mm, 19 parts (0 on the bottom side), 18 nets.

## Commit log

2026-06-10 organized
2026-06-10 added bom.csv
